Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: library.ifc
Time: 2024-09-24T21:56:50+01:00
Written by: IfcOpenShell 0.0.0
Made in: Bonsai 0.0.0
Authorization: Nobody

# IfcBuildingElementProxyType, no part of this type: batten
Material: Tanalised Timber

# IfcMemberType, no part of this type: joist
PredefinedType: RAFTER; Material: C24 Wood
Pset_MemberCommon - LoadBearing: yes

# IfcMemberType, no part of this type: purlin
PredefinedType: PURLIN; Material: Hot Rolled Steel
Pset_MemberCommon - LoadBearing: yes

# Material: Hot Rolled Steel
Pset_MaterialCommon - MassDensity: 7800
