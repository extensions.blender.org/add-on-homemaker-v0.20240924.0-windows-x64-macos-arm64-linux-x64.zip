Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: library.ifc
Time: 2024-09-24T21:52:01+01:00
Written by: IfcOpenShell 0.0.0
Made in: Bonsai 0.0.0
Authorization: Nobody

# IfcFurnitureType, no part of this type: Cinema seat 600
PredefinedType: CHAIR

# IfcMemberType, no part of this type: Cinema row
PredefinedType: STRINGER; Material: Cinema carpet
