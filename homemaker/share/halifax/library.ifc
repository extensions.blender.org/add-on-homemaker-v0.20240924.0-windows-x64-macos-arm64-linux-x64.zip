Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: library.ifc
Time: 2024-09-24T21:57:14+01:00
Written by: IfcOpenShell 0.0.0
Made in: Bonsai 0.0.0
Authorization: Nobody

# IfcCoveringType, no part of this type: crown
Description: A crown moulding from the arcade level of the Halifax Piece Hall; PredefinedType: MOLDING; Material: Sandstone

# IfcRailingType, no part of this type: balustrade_102
PredefinedType: BALUSTRADE; Material: Wrought Iron
Pset_RailingCommon - IsExternal: yes; Height: 1 m

# IfcRailingType, no part of this type: balustrade_90
PredefinedType: BALUSTRADE; Material: Wrought Iron
Pset_RailingCommon - IsExternal: yes

# IfcRailingType, no part of this type: bar
Description: A rectangular bar; PredefinedType: BALUSTRADE; Material: Wrought Iron

# IfcRailingType, no part of this type: handrail
Description: A plain wooden handrail; PredefinedType: BALUSTRADE; Material: Mahogany

# Material: Sandstone
Pset_MaterialCommon - MassDensity: 2500
Pset_MaterialEnergy - ThermalConductivityTemperatureDerivative: 0.8

# Material: Wrought Iron
Pset_MaterialCommon - MassDensity: 7800
