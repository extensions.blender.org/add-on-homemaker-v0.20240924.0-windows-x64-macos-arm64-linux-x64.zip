Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: library.ifc
Time: 2024-09-24T21:56:04+01:00
Written by: IfcOpenShell 0.0.0
Made in: Bonsai 0.0.0
Authorization: Nobody

# IfcRoofType, no part of this type: bracket
Material: Fancy timber
Pset_RoofCommon - IsExternal: yes

# IfcRoofType, no part of this type: monkey
Material: Walnut
Pset_RoofCommon - IsExternal: yes
